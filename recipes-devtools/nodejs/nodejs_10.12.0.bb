require nodejs_10.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=9ceeba79eb2ea1067b7b3ed16fff8bab"

SRC_URI[src.md5sum] = "398d2cdabdb84b3d6961afc876ed2039"
SRC_URI[src.sha256sum] = "c6552b95062f5e9f3a27da6fdb57914ab4b27a9aa2e783fb050791166554d059"

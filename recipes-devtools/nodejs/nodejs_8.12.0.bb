require nodejs_8.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=fde91d5c5bbd1e0389623e1ac018d9e8"

SRC_URI[src.md5sum] = "5690333b77964edf81945fc724f6ea85"
SRC_URI[src.sha256sum] = "b4797843136edd9195c28221a1680ae52c29d867fc5fc1c99f7d6e2f2126a67b"

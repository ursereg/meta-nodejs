require nodejs_10.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=9ceeba79eb2ea1067b7b3ed16fff8bab"

SRC_URI[src.md5sum] = "4ecb2ff4c835a669502ad98437c75123"
SRC_URI[src.sha256sum] = "3b81ea6b0ae1c887ed4215d6a0b9349284c811bd98c8ddd7a0370f6cc9eb8182"
